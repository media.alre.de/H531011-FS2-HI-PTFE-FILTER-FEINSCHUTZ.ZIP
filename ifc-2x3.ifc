Properties of the parts of a building model (IFC2X3)

# File
Description: PTFE Filter für Hygrostat HI-1 / HI1F / HI2, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H531011, PTFE Filter für Hygrostat HI-1 / HI1F / HI2
In: Raum
Description: PTFE Filter für Hygrostat HI-1 / HI1F / HI2. Feinschutz des Sensors vor Staub und Verschmutzungen.; Classification: EC002584 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H531011; ModelLabel: FS2-HI; GlobalTradeItemNumber: 4050528045355; ProductURL: https://alre.de/produkt_H531011
Pset_Specification - NominalLength: 0.09 m; NominalWidth: 0.018 m; NominalDepth: 0.018 m; NetWeight: 0.042
Pset_ALRE_ETIM_Properties - Art des mechanischen Zubehörs: Schutzkappe; Zubehör: yes; ETIM-Klasse: EC002584; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H531011.pdf
